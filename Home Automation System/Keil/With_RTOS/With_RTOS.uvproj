# Keil uVision project With_RTOS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: porting +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: ..\APP\mem_a.scf
  group APP
    ../APP/: main.c target.c IRQ.s Startup.s LCD_HEADER.h
  group UCOS-II
    ../uCosii/: OS_CORE.C OS_CPU.H OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C uCOS_II.H
  group ARM
    ../ARM/: Os_cpu_a.s Os_cpu_c.c
